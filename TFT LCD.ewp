# IAR project TFT LCD.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx1xx Luminary LM3Sx1xx
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\Luminary
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Bejeweled.bin
  ILINK.IlinkOutputFile: Bejeweled.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\Luminary\LM3S.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: startup.c
  group Lib
    Lib/: driverlib3223.a
  group Src
    Src/: Bejeweled.c cmdline.c ff.c hz16.c LTM024D130.C main.c mmc-ek-lm3s1138.c sd_card.c systemInit.c touch.c uartstdio.c
